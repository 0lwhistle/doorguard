# Keil uVision project my_work.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: my_work +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c FPM10A.c key.c lcd_12864.c main.c uart.c buzz.c led.c
